# Keil uVision project Charging_Pile.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Charging_Pile +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\stdlib\inc;..\user\api;..\user\api\delay;..\user\api\usart1;..\user\api\lcd;..\user\api\key;..\user\api\led;..\user\api\app;..\user\api\rc522;..\user\api\wb2-01s
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../startup/: startup_stm32f10x_hd.s
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
  group api
    ../user/api/delay/: delay.c
    ../user/api/: led.c key.c bsp_font.h bsp_lcd.c bsp_lcd.h hz.h img.c iccard.c mfrc522.c usart1.c esp8266.c
  group stdlib
    ../stdlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.3.0
